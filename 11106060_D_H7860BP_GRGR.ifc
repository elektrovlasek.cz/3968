Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, FMHandOverView]
File name: Project Number
Time: 2019-04-16T11:14:45
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Apr 16 11:14:45 2019 * Host: DEGTL09122 * Database: C:\Users\deschvi\AppData\Local\Temp\{1C8459F7-BA69-49B7-AF64-9C45D4D04535}\ifc * Database version: 5507 * Database creation date: Tue Apr 16 11:14:44 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Apr 16 11:14:44 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Apr 16 11:14:44 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcBuildingElementProxy: 22786035_D_11106060_H7860BP_GRGR, 11106060_D_H7860BP_GRGR:22786035_D_11106060_H7860BP_GRGR:205912
In: Level 1
Type - Classification: H7000 BP (Uniformat); Material: z_Miele_Design_Steel_Chrom, z_Miele_Design_GRGR, z_Miele_Connection_Electric, z_Miele_Design_Zinc_Steel
Pset_BuildingElementProxyCommon - Reference: 22786035_D_11106060_H7860BP_GRGR
Pset_ManufacturerTypeInformation - Manufacturer: Miele
